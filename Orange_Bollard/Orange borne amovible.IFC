Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Orange borne amovible.IFC
Time: 2020-07-02T06:05:57
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: MULT-FOU-012_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: ORAN-BOR-AMO-001-01_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 29.1764; Area Measure: 1.58524; Volume Measure: 0.00377407

# IfcBuildingElementProxy: ORAN-BOR-MUL-001_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: VEST-POT-MUL-001_Default
In: Default Storey
Material: S 235
