Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Orange borne anti-bellier.IFC
Time: 2020-07-02T06:05:25
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-AB-001_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: ORAN-BOR-MUL-002_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 23.9725; Area Measure: 1.27685; Volume Measure: 0.00311298
