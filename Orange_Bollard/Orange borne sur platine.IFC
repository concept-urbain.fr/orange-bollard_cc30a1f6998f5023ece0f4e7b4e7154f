Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Orange borne sur platine.IFC
Time: 2020-07-02T06:06:40
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ORAN-BOR-MUL-001_Default
In: Default Storey
Material: S 235

# IfcBeam: ORAN-BOR-SP-002_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 16.6451; Area Measure: 0.8827; Volume Measure: 0.0021617

# IfcBeam: ORAN-BOR-SP-003_Default
In: Default Storey
Material: S 235
