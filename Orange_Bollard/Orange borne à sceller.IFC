Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Orange borne à sceller.IFC
Time: 2020-07-02T06:06:21
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ORAN-BOR-MUL-001_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: ORAN-BOR-MUL-002_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 19.403; Area Measure: 1.05081; Volume Measure: 0.00251987
